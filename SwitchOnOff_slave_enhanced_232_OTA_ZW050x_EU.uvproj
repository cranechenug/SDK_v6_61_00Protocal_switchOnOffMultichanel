# Keil uVision project SwitchOnOff_slave_enhanced_232_OTA_ZW050x_EU.uvproj, settings and files
target SwitchOnOff_slave_enhanced_232_OTA_ZW050x_EU (MCS-51)
  device: ZW0301 Zensys
  cpu: IRAM(0-0x7F) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(32000000)
  output: SwitchOnOff_slave_enhanced_232_OTA_ZW050x_EU.aof +hex
  AfterMake: cmd /c %%TOOLSDIR%%\uVisionProjectGenerator\och51_ZW050x.bat SwitchOnOff_slave_enhanced_232_OTA_ZW050x_EU
  AfterMake: cmd /c %%TOOLSDIR%%\uVisionProjectGenerator\makeboot.bat ZW050X SwitchOnOff_slave_enhanced_232_OTA_ZW050x_EU C:\KEIL_V5\SDK\SDK_V6_61_00\Z-WAVE\
  c flags: Optimize=12
  c define: BOOTLOADER_ENABLED , EU , ZW_SLAVE, ZW_SLAVE_32, ZW_SLAVE_ENHANCED_232, ZW_SLAVE_ROUTING, ZW050x, ZW0501, NEW_NODEINFO, ZW_SELF_HEAL , BANKING , MULTI_CHANNEL_TRANSPORT , NON_BATT
  c misc: DB OE NOCO SB LC CD
  c include: ..\..\Z-WAVE\INCLUDE;..\..\Z-WAVE\IO_DEFINES;.\BUILD_PRJ;.\BUILD_PRJ\SWITCHONOFF_SLAVE_ENHANCED_232_OTA_ZW050X_EU\RELS;.\BUILD_PRJ\SWITCHONOFF_SLAVE_ENHANCED_232_OTA_ZW050X_EU;C:\KEIL_V5\C51\INC;..\APPLICATIONUTILITIES;..\APPLICATIONCOMMANDHANDLERS;..\..\ZLIB\CMDCLASS;..\..\ZLIB\DEVTYPES;..\..\ZLIB\HANDLER
  asm include: as above
  link misc: NOOVERLAY
  group Z-Wave Lib (COMMON forced)
    ../../Z-WAVE/LIB/SLAVE_ENHANCED_232_ZW050X/: ZW_SLAVE_ENHANCED_232_ZW050X.LIB
  group Z-Wave Lib (BANK1 forced)
    ../APPLICATIONUTILITIES/: ZW_FIRMWARE_BANK1_MARK.C
    ../../Z-WAVE/LIB/SLAVE_ENHANCED_232_ZW050X/: ZW_SLAVE_ENHANCED_232_ZW050X.LIB
  group Z-Wave Lib (BANK3 forced)
    ../APPLICATIONUTILITIES/: ZW_FIRMWARE_BANK3_MARK.C
    ../../Z-WAVE/LIB/SLAVE_ENHANCED_232_ZW050X/: ZW_SLAVE_ENHANCED_232_ZW050X.LIB
  group Appl Source Code (BANK2)
    ./: SwitchOnOff.c eeprom.c
    ../APPLICATIONUTILITIES/: ZW_NVM_DESCRIPTOR.C ZW_NVR_APP_API.C MANUFACTURER_SPECIFIC_DEVICE_ID.C EVENT_UTIL.C KEYMAN.C P_BUTTON.C ONE_BUTTON.C ZW_STRING.C SLAVE_LEARN_PLUS.C ASSOCIATION_PLUS.C AGI.C ZW_IO_HANDLER.C IO_ZDP03A.C APPL_TIMER.C OTA_UTIL.C ZW_CMD_CLASS_LIST.C ZW_TRANSPORTNATIVE.C ZW_TRANSPORTENDPOINT.C ENDPOINT_LOOKUP.C ZW_FIRMWARE_BANK2_MARK.C
    ../APPLICATIONCOMMANDHANDLERS/: ZW_TX_MUTEX.C COMMANDCLASSVERSION.C COMMANDCLASSPOWERLEVEL.C COMMANDCLASSDEVICERESETLOCALLY.C COMMANDCLASSASSOCIATION.C COMMANDCLASSASSOCIATIONGROUPINFO.C COMMANDCLASSMANUFACTURERSPECIFIC.C COMMANDCLASSZWAVEPLUSINFO.C COMMANDCLASSBASIC.C COMMANDCLASSBINARYSWITCH.C COMMANDCLASSFIRMWAREUPDATE.C COMMANDCLASSMULTICHAN.C COMMANDCLASSMULTICHANASSOCIATION.C
  group Appl Source Code (COMMON)
    ../../Z-WAVE/IO_DEFINES/: ZW_L51_BANK.A51 APP_RFSETUP.C ZW_APP_VERSION.A51
    ../APPLICATIONUTILITIES/: ZW_FIRMWARE_DESCRIPTOR_ADDR.C ZW_FIRMWARE_DESCRIPTOR.C
  group Z-Wave Lib (COMMON)
    ../../Z-WAVE/LIB/SLAVE_ENHANCED_232_ZW050X/: ZW_SLAVE_ENHANCED_232_ZW050X.LIB
    C:/KEIL_V5/C51//LIB/: C51FPL.LIB C51L.LIB
    ../../Z-WAVE/LIB/INIT_VARS/: INIT_VARS.OBJ
    ../../Z-WAVE/LIB/RF_FREQ/: ZW_RF_050X_EU.OBJ
  group Z-Wave Inc
    ../APPLICATIONUTILITIES/: AGI.H ZW_TRANSPORTENDPOINT.H ZW_PRODUCT_ID_ENUM.H ZW_STRING.H ASSOCIATION_PLUS.H MISC.H APPL_TIMER_API.H ZW_TRANSPORTLAYER.H ZW_TRANSPORTNATIVE.H MANUFACTURER_SPECIFIC_DEVICE_ID.H OTA_UTIL.H EVENT_UTIL.H ZW_CMD_CLASS_LIST.H ZW_NVR_APP_API.H ENDPOINT_LOOKUP.H IO_ZDP03A.H ZW_IO_HANDLER.H IO_ZM5202.H KEYMAN.H EV_MAN.H ONE_BUTTON.H P_BUTTON.H SLAVE_LEARN.H
    ../../Z-WAVE/INCLUDE/: ZW_TYPEDEFS.H ZW_SYSDEFS.H ZW0X0X.H ZW050X.H ZW_CLASSCMD.H ZW_MEM_API.H ZW_UART_API.H ZW_TRANSPORT_API.H ZW_SECURITY_API.H CONFIG_LIB.H ZW_BASIS_API.H ZW_TIMER_API.H ZW_RF050X.H ZW_NVM_DESCRIPTOR.H ZW_SLAVE_ROUTING_API.H ZW_SLAVE_API.H ZW_NODEMASK_API.H ZW_CRC.H ZW_FIRMWARE_DESCRIPTOR.H ZW_FIRMWARE_BOOTLOADER_DEFS.H ZW_NVM_EXT_API.H ZW_FIRMWARE_UPDATE_NVM_API.H ZW_NVR_API.H ZW_SLAVE_32_API.H ZW_POWER_API.H ZW_NON_ZERO.H ZW_FLASH_API.H
    ../APPLICATIONCOMMANDHANDLERS/: COMMANDCLASSASSOCIATION.H COMMANDCLASSMANUFACTURERSPECIFIC.H ZW_TX_MUTEX.H COMMANDCLASSASSOCIATIONGROUPINFO.H COMMANDCLASSBASIC.H COMMANDCLASSBINARYSWITCH.H COMMANDCLASSDEVICERESETLOCALLY.H COMMANDCLASSFIRMWAREUPDATE.H COMMANDCLASSMULTICHAN.H COMMANDCLASSMULTICHANASSOCIATION.H COMMANDCLASSPOWERLEVEL.H COMMANDCLASSVERSION.H COMMANDCLASSZWAVEPLUSINFO.H ZW_PLUS_VERSION.H
    ../../Z-WAVE/IO_DEFINES/: ZW_PINDEFS.H ZW_EVALDEFS.H
    ./: CONFIG_APP.H EEPROM.H
    C:/KEIL_V5/C51/INC/: STRING.H
